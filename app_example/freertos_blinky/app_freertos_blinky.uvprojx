# Keil uVision project app_freertos_blinky.uvprojx, settings and files
target iFlash (ARM-ADS)
  device: LPC824M201JHI33 NXP
  pack: Keil.LPC800_DFP.1.1.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: freertos_blinky
  AfterMake: ..\..\tools\keil_after_build.bat $KARM\BIN\ELFDWT.exe $KARM\ARMCC\BIN\FromElf.exe $L@L.axf $L@L.hex $L@L.bin
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0PLUS
  c include: ..\..\common\CMSIS;..\..\common\chip;..\..\common\board;..\..\peri_driver;..\..\freertos\freertos\Source\include;..\..\freertos\freertos\Source\portable\RVDS\ARM_CM0;..\..\freertos\freertoslpc;.\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Example
    ./: keil_freertos_startup_lpc82x.s main_freertos_blinky.c readme.txt
  group FreeRTOS
    ../../freertos/freertos/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../freertos/freertos/Source/portable/RVDS/ARM_CM0/: port.c
    ../../freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../freertos/freertos/Source/portable/MemMang/: heap_3.c
  group Driver
    ../../peri_driver/gpio/: gpio_8xx.c
    ../../peri_driver/uart/: uart_8xx.c ring_buffer.c
  group Common
    ../../common/chip/: sysinit_8xx.c ioswm_8xx.c clock_8xx.c syscon_8xx.c
    ../../common/board/: board.c
  group Include
    ../../peri_driver/acmp/: acmp_8xx.h
    ../../peri_driver/adc/: adc_8xx.h
    ../../peri_driver/crc/: crc_8xx.h
    ../../peri_driver/dma/: dma_8xx.h
    ../../peri_driver/gpio/: gpio_8xx.h
    ../../peri_driver/i2c/: i2c_8xx.h
    ../../peri_driver/iap/: iap.h
    ../../peri_driver/inmux/: inmux_8xx.h
    ../../peri_driver/mrt/: mrt_8xx.h
    ../../peri_driver/pinint/: pinint_8xx.h
    ../../peri_driver/pmu/: pmu_8xx.h
    ../../peri_driver/rom/: rom_i2c_8xx.h rom_pwr_8xx.h rom_uart_8xx.h romapi_8xx.h
    ../../peri_driver/sctimer/: sct_8xx.h sct_pwm_8xx.h
    ../../peri_driver/spi/: spi_8xx.h
    ../../peri_driver/uart/: uart_8xx.h ring_buffer.h
    ../../peri_driver/wkt/: wkt_8xx.h
    ../../peri_driver/wwdt/: wwdt_8xx.h
    ../../common/chip/: chip.h clock_8xx.h cmsis.h error_8xx.h ioswm_8xx.h lpc_types.h syscon_8xx.h
    ../../peri_driver/: peri_driver.h
